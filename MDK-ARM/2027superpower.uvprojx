# Keil uVision project 2027superpower.uvprojx, settings and files
target 2027superpower (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2027superpower +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../User/Bsp;../User/Algorithm;../User/App;../User/Config;../User/Calibration;../User/Procotol;../User/Debug
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c comp.c dac.c dma.c fdcan.c hrtim.c opamp.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/User/Bsp
    ../User/Bsp/: UID.c UID.h bsp_hrtim.c bsp_hrtim.h bsp_adc.c bsp_adc.h bsp_dwt.c bsp_dwt.h
  group Application/User/Algorithm
    ../User/Algorithm/: filter.c filter.h pid.c pid.h
  group Application/User/App
    ../User/App/: power_ctrl.c power_ctrl.h power_ctrl_task.c power_ctrl_task.h
  group Application/User/Config
    ../User/Config/: power_ctrl_config.h
  group Application/User/Calibration
    ../User/Calibration/: boardinfo.c boardinfo.h adc_calibration_record.c adc_calibration_record.h
  group Application/User/Procotol
    ../User/Procotol/: crc.c crc.h prot_judge.c prot_judge.h bsp_usart.c bsp_usart.h bsp_can.c bsp_can.h prot_supercap.c prot_supercap.h
  group Application/User/Debug
    ../User/Debug/: debug.c debug.h data_scope.c data_scope.h
software components: CMSIS:CORE 4.3.0
